## config/boards/shields/macrobasic/Kconfig.defconfig
```kconfig
if SHIELD_MACROBASIC

config ZMK_KEYBOARD_NAME
  default "MacroBasic"    

endif
```
